# Keil uVision project SACMCU_BootLoader.uvproj, settings and files
target SACMCU_BootLoader (ARM-ADS)
  device: LPC1227/301 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SACMCU_BootLoader +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__
  c include: ..\Source\APP;..\Source\Library\include;..\Source\CMIMS\CM0;..\Source\CMIMS\LPC12xx;..\Source\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: ..\Source\APP\mem_a.scf
  group Startup
    ../Source/CMIMS/Startup/: startup_LPC12xx.s
  group CMSIM
    ../Source/CMIMS/LPC12xx/: system_LPC12xx.c
    ../Source/CMIMS/CM0/: core_cm0.c
  group User
    ../Source/APP/: main.c
  group Lib
    ../Source/Library/source/: lpc12xx_i2c.c lpc12xx_sysctrl.c debug_frmwrk.c lpc12xx_adc.c lpc12xx_comp.c lpc12xx_crc.c lpc12xx_dma.c lpc12xx_flash.c lpc12xx_gpio.c lpc12xx_iocon.c lpc12xx_libcfg_default.c lpc12xx_pmu.c lpc12xx_rtc.c lpc12xx_ssp.c lpc12xx_timer16.c lpc12xx_timer32.c lpc12xx_uart.c lpc12xx_wdt.c
  group Document
    ../Source/APP/: main_backup
